# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  AfterMake: .\keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output .\Objects\GD32F407.bin .\Objects\GD32F407.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\SPI;..\Library\I2C;..\Library\USART;..\Hardware;..\Common;..\Hardware\i2c_oled
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: tasks_app.c App.h App_Input.c App_OTA.c App_Wifi.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c delay.c tasks.c tasks.h tasks_timer.c tasks_timer.h
  group Common
    ../Common/: flash_drv.c fmc_operation.c iap_driver.c iap_driver.h store_app.c wifi_drv.c wifi_drv.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_fwdgt.c gd32f4xx_wwdgt.c gd32f4xx_i2c.c gd32f4xx_spi.c
    ../../../../../../GD32/Projects/gd32f407_examples/Templates/GD32F407_Template_Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fmc.c
  group Library
    ../Library/: EXTI.c TIMER.c
    ../Library/SPI/: SPI0.c SPI.c
    ../Library/I2C/: I2C.c I2C0.c
  group Library/USART
    ../Library/USART/: USART.c USART0.c USART2.c
  group Library/configs
    ../Library/SPI/: SPI_config.h
    ../Library/USART/: USART_config.h
    ../Library/: EXTI_config.h TIMER_config.h
    ../Library/I2C/: I2C_config.h
  group Hardware
    ../Hardware/: bsp_keys_adv.c
    ../Hardware/i2c_oled/: oled.c
  group Doc
    ../Doc/: readme.txt
